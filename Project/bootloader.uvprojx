# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L_bin" "#L"
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --text -a -c -o "$L@L.dis" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Hardware;..\Libraries\cm_backtrace\Languages\en-US;..\Libraries\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\bootloader.sct
  group strartup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group fwlib
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../User/: main.c bridge.c iapram.c
    ./Objects/: bootloader.dis bootloader.sct
  group bsp
    ../Hardware/: usart.c
  group cm_backtrace
    ../Libraries/cm_backtrace/: cm_backtrace.c
    ../Libraries/cm_backtrace/fault_handler/keil/: cmb_fault.S
